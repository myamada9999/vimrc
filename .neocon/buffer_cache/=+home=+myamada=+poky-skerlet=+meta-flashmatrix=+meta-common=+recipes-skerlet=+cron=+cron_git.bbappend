[{'word': 'inherit', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'inherit'}, {'word': 'update', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'update'}, {'word': 'INITSCRIPT_NAME', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'INITSCRIPT_NAME'}, {'word': 'cron', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'cron'}, {'word': 'INITSCRIPT_PARAMS', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'INITSCRIPT_PARAMS'}, {'word': 'defaults', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'defaults'}, {'word': 'do_install_append', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'install', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'install'}, {'word': 'debian', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'debian'}, {'word': 'crontab', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'crontab'}, {'word': 'main', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'main'}, {'word': 'sysconfdir', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'hourly', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'hourly'}, {'word': 'daily', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'daily'}, {'word': 'weekly', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'weekly'}, {'word': 'monthly', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'monthly'}, {'word': 'localstatedir', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'localstatedir'}, {'word': 'spool', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'spool'}, {'word': 'crontabs', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'crontabs'}, {'word': 'busybox', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'busybox'}, {'word': 'parts', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'parts'}, {'word': 'does', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'does'}, {'word': 'understand', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'understand'}, {'word': 'report', 'menu': '[B] cron_git.bbappe', 'kind': '', 'abbr': 'report'}]
