[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'file'}, {'word': 'busybox', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'busybox'}, {'word': 'defconfig', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'defconfig'}, {'word': 'BUSYBOX_CONFIG', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'BUSYBOX_CONFIG'}, {'word': 'BUSYBOX_INITTAB_RESPAWN', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'BUSYBOX_INITTAB_RESPAWN'}, {'word': 'base_sbindir', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'base_sbindir'}, {'word': 'getty', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'getty'}, {'word': 'tty1', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'tty1'}, {'word': 'SERIAL_CONSOLE', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'SERIAL_CONSOLE'}, {'word': 'BUSYBOX_INITTAB_ONCE', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'BUSYBOX_INITTAB_ONCE'}, {'word': 'sysconfdir', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'init', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'init'}, {'word': 'load', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'load'}, {'word': 'keys', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'keys'}, {'word': 'DEPENDS', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'DEPENDS'}, {'word': 'libpam', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'libpam'}, {'word': 'do_install_append', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'remove', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'remove'}, {'word': 'symbolic', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'symbolic'}, {'word': 'link', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'link'}, {'word': 'sbin', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'sbin'}, {'word': 'syslogd', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'syslogd'}, {'word': 'links', 'menu': '[B] busybox_git.bba', 'kind': '', 'abbr': 'links'}]
