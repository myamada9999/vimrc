[{'word': 'SKERLET_EXTRA_RDEPENDS', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'SKERLET_EXTRA_RDEPENDS'}, {'word': 'crash', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'crash'}, {'word': 'kexec', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'kexec'}, {'word': 'tools', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tools'}, {'word': 'makedumpfile', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'makedumpfile'}, {'word': 'gdbserver', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'gdbserver'}, {'word': 'eglibc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'eglibc'}, {'word': 'libsegfault', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libsegfault'}, {'word': 'libmemusage', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libmemusage'}]
