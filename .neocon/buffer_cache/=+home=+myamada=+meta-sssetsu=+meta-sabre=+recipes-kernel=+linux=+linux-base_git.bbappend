[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'files', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'files'}, {'word': 'SRC_URI', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'file'}, {'word': 'imx6q', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'imx6q'}, {'word': 'drop', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'drop'}, {'word': 'unnecessary', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'unnecessary'}, {'word': 'semicolon', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'semicolon'}, {'word': 'patch', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'patch'}, {'word': 'video', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'video'}, {'word': 'divider', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'divider'}, {'word': 'imx6sl', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'imx6sl'}, {'word': 'Disable', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'Disable'}, {'word': 'specific', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'specific'}, {'word': 'code', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'code'}, {'word': 'when', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'when'}, {'word': 'sdhci', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'sdhci'}, {'word': 'esdhc', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'esdhc'}, {'word': 'Fixup', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'Fixup'}, {'word': 'runtime', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'runtime'}, {'word': 'conditions', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'conditions'}, {'word': 'duri', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'duri'}, {'word': 'Revert', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'Revert'}, {'word': 'warning', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'warning'}, {'word': 'found', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'found'}, {'word': 'debug', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'debug'}, {'word': 'rt25', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'rt25'}, {'word': 'build', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'build'}, {'word': 'with', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'with'}, {'word': 'enabled', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'enabled'}, {'word': 'split', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'split'}, {'word': 'ptlocks', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'ptlocks'}, {'word': 'sdma', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'sdma'}, {'word': 'channel', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'channel'}, {'word': 'spinlock', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'spinlock'}, {'word': 'defconfig', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'defconfig'}, {'word': 'conf', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'conf'}, {'word': 'LINUX_CONFIG', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_CONFIG'}]
