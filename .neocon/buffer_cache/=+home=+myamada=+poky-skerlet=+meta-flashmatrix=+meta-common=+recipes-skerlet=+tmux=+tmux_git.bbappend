[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'file'}, {'word': '_tmux', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': '_tmux'}, {'word': 'do_install_append', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'volatile', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'volatile'}, {'word': 'rmdir', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'rmdir'}, {'word': 'tmux', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'tmux'}, {'word': 'install', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'install'}, {'word': 'sysconfdir', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'default', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'default'}, {'word': 'volatiles', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'volatiles'}, {'word': 'WORKDIR', 'menu': '[B] tmux_git.bbappe', 'kind': '', 'abbr': 'WORKDIR'}]
