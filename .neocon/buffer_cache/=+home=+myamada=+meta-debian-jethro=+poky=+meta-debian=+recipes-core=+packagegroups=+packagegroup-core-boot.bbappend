[{'word': 'RDEPENDS_', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'RDEPENDS_'}, {'word': 'dpkg', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'dpkg'}, {'word': 'update', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'update'}, {'word': 'alternatives', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'alternatives'}, {'word': 'sysvinit', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'sysvinit'}, {'word': 'core', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'core'}, {'word': 'utils', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'utils'}]
