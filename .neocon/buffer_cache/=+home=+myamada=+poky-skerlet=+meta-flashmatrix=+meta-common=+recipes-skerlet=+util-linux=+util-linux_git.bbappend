[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'file'}, {'word': 'hwclock', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'hwclock'}, {'word': 'inherit', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'inherit'}, {'word': 'update', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'update'}, {'word': 'util', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'util'}, {'word': 'linux', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'linux'}, {'word': 'install', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'install'}, {'word': 'only', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'only'}, {'word': 'PACKAGES', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'PACKAGES'}, {'word': 'FILES_', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'FILES_'}, {'word': 'base_sbindir', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'base_sbindir'}, {'word': 'sysconfdir', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'init', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'init'}, {'word': 'do_install_append', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'WORKDIR', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'pkg_postinst_', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'pkg_postinst_'}, {'word': 'fsck', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'fsck'}, {'word': 'higher', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'higher'}, {'word': 'priority', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'priority'}, {'word': 'than', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'than'}, {'word': 'busybox', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'busybox'}, {'word': 'alternatives', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'alternatives'}, {'word': 'INITSCRIPT_PACKAGES', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'INITSCRIPT_PACKAGES'}, {'word': 'INITSCRIPT_NAME_', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'INITSCRIPT_NAME_'}, {'word': 'INITSCRIPT_PARAMS_', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'INITSCRIPT_PARAMS_'}, {'word': 'start', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'start'}, {'word': 'stop', 'menu': '[B] util-linux_git.', 'kind': '', 'abbr': 'stop'}]
