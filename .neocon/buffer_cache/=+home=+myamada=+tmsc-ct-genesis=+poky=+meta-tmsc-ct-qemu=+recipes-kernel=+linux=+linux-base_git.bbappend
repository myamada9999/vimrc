[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'files', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'files'}, {'word': 'LINUX_DEFCONFIG', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_DEFCONFIG'}, {'word': 'default', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'default'}, {'word': 'config', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'config'}, {'word': 'LINUX_CONFIG_APPEND', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_CONFIG_APPEND'}, {'word': 'MACHINE', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'MACHINE'}, {'word': 'local', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'local'}, {'word': 'configuration', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'configuration'}, {'word': 'file', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'file'}, {'word': 'SRC_URI', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'LINUX_CONFIG', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_CONFIG'}, {'word': 'default1', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'default1'}, {'word': 'string', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'string'}, {'word': 'MODULE_DESCRIPTION', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'MODULE_DESCRIPTION'}, {'word': 'field', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'field'}, {'word': 'drivers', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'drivers'}, {'word': 'nand', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'nand'}, {'word': 'cafe_nand', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'cafe_nand'}, {'word': 'causes', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'causes'}, {'word': 'error', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'error'}, {'word': 'do_package_write_deb', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'do_package_write_deb'}, {'word': 'remove', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'remove'}, {'word': 'from', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'from'}, {'word': 'cafe', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'cafe'}, {'word': 'description', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'description'}, {'word': 'patch', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'patch'}]
