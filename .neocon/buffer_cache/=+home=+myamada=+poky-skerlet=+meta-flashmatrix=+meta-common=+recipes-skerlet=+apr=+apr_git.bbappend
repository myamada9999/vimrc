[{'word': 'EXTRA_OECONF', 'menu': '[B] apr_git.bbappen', 'kind': '', 'abbr': 'EXTRA_OECONF'}, {'word': 'apr_cv_epoll', 'menu': '[B] apr_git.bbappen', 'kind': '', 'abbr': 'apr_cv_epoll'}]
