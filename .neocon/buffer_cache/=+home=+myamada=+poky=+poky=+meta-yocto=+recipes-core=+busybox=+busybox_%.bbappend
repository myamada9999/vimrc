[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] busybox_%.bbapp', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] busybox_%.bbapp', 'kind': '', 'abbr': 'THISDIR'}]
