[{'word': 'require', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'require'}, {'word': 'recipes', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'recipes'}, {'word': 'kernel', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'kernel'}, {'word': 'linux', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'linux'}, {'word': 'perf', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'perf'}, {'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'rename', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'rename'}, {'word': 'bzImage', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'bzImage'}, {'word': 'vmlinuz', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'vmlinuz'}, {'word': 'inherit', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'inherit'}, {'word': 'skerlet', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'skerlet'}, {'word': 'local', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'local'}, {'word': 'configuration', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'configuration'}, {'word': 'file', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'file'}, {'word': 'SRC_URI', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'flashmatrix', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'flashmatrix'}, {'word': 'defconfig', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'defconfig'}, {'word': 'LINUX_CONF', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'LINUX_CONF'}, {'word': 'WORKDIR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'SCRIPTING_DEFINES', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'SCRIPTING_DEFINES'}, {'word': 'ARCH', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'ARCH'}, {'word': 'x86_64', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'x86_64'}, {'word': 'WERROR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'WERROR'}]
