[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'file'}, {'word': 'defconfig', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'defconfig'}, {'word': 'BUSYBOX_CONFIG', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'BUSYBOX_CONFIG'}, {'word': 'BUSYBOX_INITTAB_RESPAWN', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'BUSYBOX_INITTAB_RESPAWN'}, {'word': 'base_sbindir', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'base_sbindir'}, {'word': 'getty', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'getty'}, {'word': 'tty1', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'tty1'}, {'word': 'SERIAL_CONSOLE', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'SERIAL_CONSOLE'}, {'word': 'BUSYBOX_INITTAB_ONCE', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'BUSYBOX_INITTAB_ONCE'}, {'word': 'sysconfdir', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'init', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'init'}, {'word': 'load', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'load'}, {'word': 'keys', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'keys'}, {'word': 'DEPENDS', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'DEPENDS'}, {'word': 'libpam', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'libpam'}, {'word': 'shadow', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'shadow'}, {'word': 'do_install_append', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'remove', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'remove'}, {'word': 'symbolic', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'symbolic'}, {'word': 'link', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'link'}, {'word': 'sbin', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'sbin'}, {'word': 'syslogd', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'syslogd'}, {'word': 'busybox', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'busybox'}, {'word': 'links', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'links'}]
