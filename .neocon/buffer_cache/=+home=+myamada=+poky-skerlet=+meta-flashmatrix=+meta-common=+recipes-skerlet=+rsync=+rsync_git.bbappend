[{'word': 'do_install_append', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'install', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'install'}, {'word': 'sysconfdir', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'logrotate', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'logrotate'}, {'word': 'debian', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'debian'}, {'word': 'conf', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'conf'}, {'word': 'rsync', 'menu': '[B] rsync_git.bbapp', 'kind': '', 'abbr': 'rsync'}]
