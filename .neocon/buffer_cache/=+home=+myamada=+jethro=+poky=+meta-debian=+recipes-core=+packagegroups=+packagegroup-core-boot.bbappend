[{'word': 'RDEPENDS_', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'RDEPENDS_'}, {'word': 'dpkg', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'dpkg'}, {'word': 'update', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'update'}, {'word': 'alternatives', 'menu': '[B] packagegroup-co', 'kind': '', 'abbr': 'alternatives'}]
