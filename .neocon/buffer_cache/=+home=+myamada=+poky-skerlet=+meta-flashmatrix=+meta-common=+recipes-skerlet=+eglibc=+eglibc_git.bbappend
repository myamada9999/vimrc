[{'word': 'FILES_ldd', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'FILES_ldd'}, {'word': 'PKGSUFFIX', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'PKGSUFFIX'}, {'word': 'lib64', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'lib64'}, {'word': 'do_install_append', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'create', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'create'}, {'word': 'symbolic', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'symbolic'}, {'word': 'link', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'link'}, {'word': 'target', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'target'}, {'word': 'x86_64', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'x86_64'}, {'word': 'SITEINFO_BITS', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'SITEINFO_BITS'}, {'word': 'then', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'then'}, {'word': 'install', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'install'}, {'word': 'pushd', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'pushd'}, {'word': 'linux', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'linux'}, {'word': 'popd', 'menu': '[B] eglibc_git.bbap', 'kind': '', 'abbr': 'popd'}]
