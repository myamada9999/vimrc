[{'word': 'SKERLET_EXTRA_RDEPENDS', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'SKERLET_EXTRA_RDEPENDS'}, {'word': 'kernel', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'kernel'}, {'word': 'image', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'image'}, {'word': 'modules', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'modules'}, {'word': 'findutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'findutils'}, {'word': 'lvm2', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'lvm2'}, {'word': 'coreutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'coreutils'}, {'word': 'module', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'module'}, {'word': 'init', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'init'}, {'word': 'tools', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tools'}, {'word': 'busybox', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'busybox'}, {'word': 'base', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'base'}, {'word': 'files', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'files'}, {'word': 'util', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'util'}, {'word': 'linux', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'linux'}, {'word': 'hwclock', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'hwclock'}, {'word': 'udev', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'udev'}, {'word': 'extraconf', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'extraconf'}, {'word': 'keymaps', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'keymaps'}, {'word': 'freetype', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'freetype'}, {'word': 'gettext', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'gettext'}, {'word': 'readline', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'readline'}, {'word': 'popt', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'popt'}, {'word': 'mingetty', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'mingetty'}, {'word': 'libusb1', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libusb1'}, {'word': 'usbutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'usbutils'}, {'word': 'pciutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pciutils'}, {'word': 'utils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'utils'}, {'word': 'gdbm', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'gdbm'}, {'word': 'expat', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'expat'}, {'word': 'wrappers', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'wrappers'}, {'word': 'netbase', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'netbase'}, {'word': 'glib', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'glib'}, {'word': 'zlib', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'zlib'}, {'word': 'passwd', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'passwd'}, {'word': 'cracklib', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'cracklib'}, {'word': 'libcap', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libcap'}, {'word': 'attr', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'attr'}, {'word': 'bash', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'bash'}, {'word': 'ncurses', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ncurses'}, {'word': 'rsync', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'rsync'}, {'word': 'whichman', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'whichman'}, {'word': 'libaio', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libaio'}, {'word': 'procps', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'procps'}, {'word': 'e2fsprogs', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'e2fsprogs'}, {'word': 'mke2fs', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'mke2fs'}, {'word': 'e2fsck', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'e2fsck'}, {'word': 'openssh', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'openssh'}, {'word': 'keygen', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'keygen'}, {'word': 'keys', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'keys'}, {'word': 'misc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'misc'}, {'word': 'sftp', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'sftp'}, {'word': 'server', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'server'}, {'word': 'sshd', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'sshd'}, {'word': 'perl', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'perl'}, {'word': 'tickadj', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tickadj'}, {'word': 'ntpdate', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ntpdate'}, {'word': 'ntpsweep', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ntpsweep'}, {'word': 'rsyslog', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'rsyslog'}, {'word': 'watchdog', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'watchdog'}, {'word': 'pwauth', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pwauth'}, {'word': 'auth', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'auth'}, {'word': 'openldap', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'openldap'}, {'word': 'slapd', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'slapd'}, {'word': 'ldapd', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ldapd'}, {'word': 'libpam', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libpam'}, {'word': 'openssl', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'openssl'}, {'word': 'adduser', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'adduser'}, {'word': 'libpython3', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libpython3'}, {'word': 'python3', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'python3'}, {'word': 'audio', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'audio'}, {'word': 'codecs', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'codecs'}, {'word': 'compile', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'compile'}, {'word': 'compression', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'compression'}, {'word': 'core', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'core'}, {'word': 'crypt', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'crypt'}, {'word': 'ctypes', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ctypes'}, {'word': 'curses', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'curses'}, {'word': 'datetime', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'datetime'}, {'word': 'difflib', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'difflib'}, {'word': 'distutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'distutils'}, {'word': 'elementtree', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'elementtree'}, {'word': 'email', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'email'}, {'word': 'fcntl', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'fcntl'}, {'word': 'html', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'html'}, {'word': 'idle', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'idle'}, {'word': 'importlib', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'importlib'}, {'word': 'json', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'json'}, {'word': 'lang', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'lang'}, {'word': 'logging', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'logging'}, {'word': 'mailbox', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'mailbox'}, {'word': 'math', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'math'}, {'word': 'mime', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'mime'}, {'word': 'mmap', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'mmap'}, {'word': 'multiprocessing', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'multiprocessing'}, {'word': 'netclient', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'netclient'}, {'word': 'netserver', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'netserver'}, {'word': 'numbers', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'numbers'}, {'word': 'pickle', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pickle'}, {'word': 'pkgutil', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pkgutil'}, {'word': 'pprint', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pprint'}, {'word': 'profile', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'profile'}, {'word': 'pydoc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'pydoc'}, {'word': 'resource', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'resource'}, {'word': 'robotparser', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'robotparser'}, {'word': 'shell', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'shell'}, {'word': 'smtpd', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'smtpd'}, {'word': 'sqlite3', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'sqlite3'}, {'word': 'tests', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tests'}, {'word': 'stringold', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'stringold'}, {'word': 'subprocess', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'subprocess'}, {'word': 'syslog', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'syslog'}, {'word': 'terminal', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'terminal'}, {'word': 'textutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'textutils'}, {'word': 'threading', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'threading'}, {'word': 'tkinter', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tkinter'}, {'word': 'unixadmin', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'unixadmin'}, {'word': 'xmlrpc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'xmlrpc'}, {'word': 'argparse', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'argparse'}, {'word': 'python', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'python'}, {'word': 'smbus', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'smbus'}, {'word': 'logrotate', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'logrotate'}, {'word': 'eglibc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'eglibc'}, {'word': 'file', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'file'}, {'word': 'tzdata', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tzdata'}, {'word': 'libedit', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libedit'}, {'word': 'gawk', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'gawk'}, {'word': 'sudo', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'sudo'}, {'word': 'ldap', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ldap'}, {'word': 'sshpass', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'sshpass'}, {'word': 'iptables', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'iptables'}, {'word': 'Developer', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'Developer'}, {'word': 'packages', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'packages'}, {'word': 'comment', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'comment'}, {'word': 'release', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'release'}, {'word': 'libc', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libc'}, {'word': 'headers', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'headers'}, {'word': 'binutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'binutils'}, {'word': 'ethtool', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ethtool'}, {'word': 'strace', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'strace'}, {'word': 'oprofile', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'oprofile'}, {'word': 'flex', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'flex'}, {'word': 'bison', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'bison'}, {'word': 'diffutils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'diffutils'}, {'word': 'trace', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'trace'}, {'word': 'htop', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'htop'}, {'word': 'libsegfault', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libsegfault'}, {'word': 'libmemusage', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'libmemusage'}, {'word': 'lrzsz', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'lrzsz'}, {'word': 'ltrace', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ltrace'}, {'word': 'tcpdump', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tcpdump'}, {'word': 'iputils', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'iputils'}, {'word': 'ping', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'ping'}, {'word': 'iperf', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'iperf'}, {'word': 'crash', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'crash'}, {'word': 'kexec', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'kexec'}, {'word': 'makedumpfile', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'makedumpfile'}, {'word': 'gdbserver', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'gdbserver'}, {'word': 'perf', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'perf'}, {'word': 'lsof', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'lsof'}, {'word': 'iotop', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'iotop'}, {'word': 'tmux', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'tmux'}, {'word': 'screen', 'menu': '[B] task-base-skerl', 'kind': '', 'abbr': 'screen'}]
