[{'word': 'LICENSE', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'LICENSE'}, {'word': 'GPLv2', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'GPLv2'}, {'word': 'LIC_FILES_CHKSUM', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'LIC_FILES_CHKSUM'}, {'word': 'file', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'file'}, {'word': 'COPYING', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'COPYING'}, {'word': 'aa954499f7abaabaa882bbe', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'aa954499f7abaabaa882bbe'}, {'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SKERLET_FILES_PASSWD', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'SKERLET_FILES_PASSWD'}, {'word': 'passwd', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'passwd'}, {'word': 'SKERLET_FILES_GROUP', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'SKERLET_FILES_GROUP'}, {'word': 'group', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'group'}, {'word': 'SRC_URI', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'home', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'home'}, {'word': 'directories', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'directories'}, {'word': 'profile', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'profile'}, {'word': 'root', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'root'}, {'word': 'install_home', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'install_home'}, {'word': 'echo', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'echo'}, {'word': 'install', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'install'}, {'word': 'WORKDIR', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'FILES_', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'FILES_'}, {'word': 'miscellaneous', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'miscellaneous'}, {'word': 'load', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'load'}, {'word': 'keys', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'keys'}, {'word': 'populate', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'populate'}, {'word': 'volatile', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'volatile'}, {'word': 'volatiles', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'volatiles'}, {'word': 'hostname', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'hostname'}, {'word': 'patch', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'patch'}, {'word': 'stop', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'stop'}, {'word': 'cpld', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'cpld'}, {'word': 'watchdog', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'watchdog'}, {'word': 'install_misc', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'install_misc'}, {'word': 'sysconfdir', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'init', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'init'}, {'word': 'tmpfs', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'tmpfs'}, {'word': 'defaults', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'defaults'}, {'word': 'fstab', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'fstab'}, {'word': 'default', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'default'}, {'word': '_core', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': '_core'}, {'word': 'update', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'update'}, {'word': 'start', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'start'}, {'word': 'CPLD', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'CPLD'}, {'word': 'timer', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'timer'}, {'word': 'boot', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'boot'}, {'word': 'time', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'time'}, {'word': 'with', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'with'}, {'word': 'S21stop', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'S21stop'}, {'word': 'MACHINE', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'MACHINE'}, {'word': 'qemux86', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'qemux86'}, {'word': 'then', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'then'}, {'word': 'online', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'online'}, {'word': 'tools', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'tools'}, {'word': 'revert', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'revert'}, {'word': 'factory', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'factory'}, {'word': 'install_online_update_tools', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'install_online_update_tools'}, {'word': 'script', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'script'}, {'word': 'sbindir', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'sbindir'}, {'word': 'environment', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'environment'}, {'word': 'save', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'save'}, {'word': 'S99update', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'S99update'}, {'word': 'reset', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'reset'}, {'word': 'S07factory', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'S07factory'}, {'word': 'do_install_append', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'do_install_append'}]
