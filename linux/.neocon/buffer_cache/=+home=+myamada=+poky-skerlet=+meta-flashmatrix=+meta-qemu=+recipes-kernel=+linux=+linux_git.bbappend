[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'local', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'local'}, {'word': 'configuration', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'configuration'}, {'word': 'file', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'file'}, {'word': 'SRC_URI', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'qemu', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'qemu'}, {'word': 'do_defconfig_prepend', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'do_defconfig_prepend'}, {'word': 'CONFIG_E1000', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'CONFIG_E1000'}, {'word': 'LINUX_CONF', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'LINUX_CONF'}, {'word': 'do_deploy_append', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'do_deploy_append'}, {'word': 'install', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'install'}, {'word': 'WORKDIR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'DEPLOYDIR', 'menu': '[B] linux_git.bbapp', 'kind': '', 'abbr': 'DEPLOYDIR'}]
