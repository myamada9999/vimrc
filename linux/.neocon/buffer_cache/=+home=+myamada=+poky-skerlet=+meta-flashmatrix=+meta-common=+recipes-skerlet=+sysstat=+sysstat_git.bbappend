[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'file'}, {'word': '_sysstat', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': '_sysstat'}, {'word': 'do_install_append', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'install', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'install'}, {'word': 'default', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'default'}, {'word': 'volatiles', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'volatiles'}, {'word': 'WORKDIR', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'pkg_postinst_', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'pkg_postinst_'}, {'word': 'init', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'init'}, {'word': 'populate', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'populate'}, {'word': 'volatile', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'volatile'}, {'word': 'update', 'menu': '[B] sysstat_git.bba', 'kind': '', 'abbr': 'update'}]
