[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'files', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'files'}, {'word': 'local', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'local'}, {'word': 'configuration', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'configuration'}, {'word': 'file', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'file'}, {'word': 'LINUX_CONFIG_APPEND', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_CONFIG_APPEND'}, {'word': 'qemux86', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'qemux86'}, {'word': 'config', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'config'}]
