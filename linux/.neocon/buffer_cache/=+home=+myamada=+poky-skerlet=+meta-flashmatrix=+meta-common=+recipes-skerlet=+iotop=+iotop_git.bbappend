[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'file'}, {'word': 'v3format', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'v3format'}, {'word': 'patch', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'patch'}, {'word': 'RDEPENDS_', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'RDEPENDS_'}, {'word': 'python3', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'python3'}, {'word': 'curses', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'curses'}, {'word': 'textutils', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'textutils'}, {'word': 'codecs', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'codecs'}, {'word': 'ctypes', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'ctypes'}, {'word': 'pprint', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'pprint'}, {'word': 'shell', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'shell'}, {'word': 'RDEPENDS', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'RDEPENDS'}, {'word': 'PYTHON_BASEVERSION', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'PYTHON_BASEVERSION'}, {'word': 'distutils_do_install', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'distutils_do_install'}, {'word': 'install', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'install'}, {'word': 'PYTHON_SITEPACKAGES_DIR', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'PYTHON_SITEPACKAGES_DIR'}, {'word': 'STAGING_INCDIR', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'STAGING_INCDIR'}, {'word': 'STAGING_LIBDIR', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'STAGING_LIBDIR'}, {'word': 'PYTHONPATH', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'PYTHONPATH'}, {'word': 'BUILD_SYS', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'BUILD_SYS'}, {'word': 'HOST_SYS', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'HOST_SYS'}, {'word': 'using', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'using'}, {'word': 'native', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'native'}, {'word': 'STAGING_BINDIR_NATIVE', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'STAGING_BINDIR_NATIVE'}, {'word': 'setup', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'setup'}, {'word': 'DISTUTILS_INSTALL_ARGS', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'DISTUTILS_INSTALL_ARGS'}, {'word': 'bbfatal', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'bbfatal'}, {'word': 'python', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'python'}, {'word': 'execution', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'execution'}, {'word': 'failed', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'failed'}, {'word': 'find', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'find'}, {'word': 'name', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'name'}, {'word': 'done', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'done'}, {'word': 'test', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'test'}, {'word': 'bindir', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'bindir'}, {'word': 'then', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'then'}, {'word': 'sbindir', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'sbindir'}, {'word': 'easy', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'easy'}, {'word': 'FIXME', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'FIXME'}, {'word': 'Bandaid', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'Bandaid'}, {'word': 'against', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'against'}, {'word': 'wrong', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'wrong'}, {'word': 'datadir', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'datadir'}, {'word': 'computation', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'computation'}, {'word': 'share', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'share'}, {'word': 'These', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'These'}, {'word': 'generated', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'generated'}, {'word': 'files', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'files'}, {'word': 'really', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'really'}, {'word': 'slow', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'slow'}, {'word': 'systems', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'systems'}, {'word': 'storage', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'storage'}, {'word': 'speed', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'speed'}, {'word': 'trade', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'trade'}, {'word': 'might', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'might'}, {'word': 'worth', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'worth'}, {'word': 'general', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'general'}, {'word': 'libdir', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'libdir'}, {'word': 'PYTHON_DIR', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'PYTHON_DIR'}, {'word': 'site', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'site'}, {'word': 'packages', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'packages'}, {'word': 'iname', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'iname'}, {'word': 'exec', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'exec'}, {'word': 'do_install_append', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'default', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'default'}, {'word': 'iotop', 'menu': '[B] iotop_git.bbapp', 'kind': '', 'abbr': 'iotop'}]
