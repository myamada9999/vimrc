[{'word': 'KBRANCH_genericx86', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'KBRANCH_genericx86'}, {'word': 'standard', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'standard'}, {'word': 'base', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'base'}, {'word': 'KBRANCH_edgerouter', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'KBRANCH_edgerouter'}, {'word': 'edgerouter', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'edgerouter'}, {'word': 'KBRANCH_beaglebone', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'KBRANCH_beaglebone'}, {'word': 'beaglebone', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'beaglebone'}, {'word': 'KBRANCH_mpc8315e', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'KBRANCH_mpc8315e'}, {'word': 'mpc8315e', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'mpc8315e'}, {'word': 'KMACHINE_genericx86', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'KMACHINE_genericx86'}, {'word': 'common', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'common'}, {'word': 'SRCREV_machine_genericx86', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'SRCREV_machine_genericx86'}, {'word': 'c22dc676d6d560d0b2a316283a514d65d2a510e4', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'c22dc676d6d560d0b2a316283a514d65d2a510e4'}, {'word': 'SRCREV_machine_edgerouter', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'SRCREV_machine_edgerouter'}, {'word': 'a31b9d23db126f8a6be3eb88fd683056a213f1', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'a31b9d23db126f8a6be3eb88fd683056a213f1'}, {'word': 'SRCREV_machine_beaglebone', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'SRCREV_machine_beaglebone'}, {'word': 'efb6ffb2ca96a364f916c9890ad023fc595e0e6e', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'efb6ffb2ca96a364f916c9890ad023fc595e0e6e'}, {'word': 'SRCREV_machine_mpc8315e', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'SRCREV_machine_mpc8315e'}, {'word': 'COMPATIBLE_MACHINE_genericx86', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'COMPATIBLE_MACHINE_genericx86'}, {'word': 'genericx86', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'genericx86'}, {'word': 'COMPATIBLE_MACHINE_edgerouter', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'COMPATIBLE_MACHINE_edgerouter'}, {'word': 'COMPATIBLE_MACHINE_beaglebone', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'COMPATIBLE_MACHINE_beaglebone'}, {'word': 'COMPATIBLE_MACHINE_mpc8315e', 'menu': '[B] linux-yocto_4.1', 'kind': '', 'abbr': 'COMPATIBLE_MACHINE_mpc8315e'}]
