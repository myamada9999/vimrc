[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'SRC_URI', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'file'}, {'word': 'interfaces', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'interfaces'}, {'word': 'do_install_append', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'do_install_append'}, {'word': 'install', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'install'}, {'word': 'sysconfdir', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'sysconfdir'}, {'word': 'network', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'network'}, {'word': 'WORKDIR', 'menu': '[B] skerlet-files_1', 'kind': '', 'abbr': 'WORKDIR'}]
