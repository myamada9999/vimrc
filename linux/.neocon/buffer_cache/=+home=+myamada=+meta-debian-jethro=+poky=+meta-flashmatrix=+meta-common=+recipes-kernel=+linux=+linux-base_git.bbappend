[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'files', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'files'}, {'word': 'local', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'local'}, {'word': 'configuration', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'configuration'}, {'word': 'file', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'file'}, {'word': 'LINUX_CONFIG', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LINUX_CONFIG'}, {'word': 'flashmatrix', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'flashmatrix'}, {'word': 'defconfig', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'defconfig'}, {'word': 'SCRIPTING_DEFINES', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SCRIPTING_DEFINES'}, {'word': 'ARCH', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'ARCH'}, {'word': 'x86_64', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'x86_64'}, {'word': 'WERROR', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'WERROR'}, {'word': 'ltsi', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'ltsi'}, {'word': 'kernel', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'kernel'}, {'word': 'LTSI_KERNEL_GIT_URI', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_GIT_URI'}, {'word': 'linuxfoundation', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'linuxfoundation'}, {'word': 'LTSI_KERNEL_GIT_REPO', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_GIT_REPO'}, {'word': 'LTSI_KERNEL_GIT_PROTOCOL', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_GIT_PROTOCOL'}, {'word': 'http', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'http'}, {'word': 'LTSI_KERNEL_GIT_BRANCH', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_GIT_BRANCH'}, {'word': 'master', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'master'}, {'word': 'LTSI_KERNEL_GIT_SRCREV', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_GIT_SRCREV'}, {'word': 'SRCREV_ltsi', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SRCREV_ltsi'}, {'word': 'LTSI_KERNEL_SRC_URI', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'LTSI_KERNEL_SRC_URI'}, {'word': 'destsuffix', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'destsuffix'}, {'word': 'branch', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'branch'}, {'word': 'name', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'name'}, {'word': 'protocol', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'protocol'}, {'word': 'SRC_URI', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'base_conditional', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'base_conditional'}, {'word': 'SRCREV_FORMAT', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'SRCREV_FORMAT'}, {'word': 'kernel_linux', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'kernel_linux'}, {'word': 'do_patch_prepend', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'do_patch_prepend'}, {'word': 'build', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'build'}, {'word': 'exec_func', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'exec_func'}, {'word': 'do_ltsi_kernel_generate_git', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'do_ltsi_kernel_generate_git'}, {'word': 'then', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'then'}, {'word': 'scripts', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'scripts'}, {'word': 'generate_git', 'menu': '[B] linux-base_git.', 'kind': '', 'abbr': 'generate_git'}]
