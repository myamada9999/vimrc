[{'word': 'FILESEXTRAPATHS_prepend', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'FILESEXTRAPATHS_prepend'}, {'word': 'THISDIR', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'THISDIR'}, {'word': 'special', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'special'}, {'word': 'configuration', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'configuration'}, {'word': 'BUSYBOX_CONFIG', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'BUSYBOX_CONFIG'}, {'word': 'config', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'config'}, {'word': 'syslog', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'syslog'}, {'word': 'BUSYBOX_SYSLOG_CONF', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'BUSYBOX_SYSLOG_CONF'}, {'word': 'conf', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'conf'}, {'word': 'SRC_URI', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'SRC_URI'}, {'word': 'file', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'file'}, {'word': 'rename_local_file', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'rename_local_file'}, {'word': 'LOCAL', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'LOCAL'}, {'word': 'DEFAULT', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'DEFAULT'}, {'word': 'WORKDIR', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'WORKDIR'}, {'word': 'rename_local_files', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'rename_local_files'}, {'word': 'defconfig', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'defconfig'}, {'word': 'python', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'python'}, {'word': 'do_unpack_append', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'do_unpack_append'}, {'word': 'build', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'build'}, {'word': 'exec_func', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'exec_func'}, {'word': 'do_configure_prepend', 'menu': '[B] busybox_debian.', 'kind': '', 'abbr': 'do_configure_prepend'}]
